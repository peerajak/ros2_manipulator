Commit message: object detection added

File: grasp_box2.urdf (robot description, URDF)
Before this commit: robot grasp_box, 1 links, 0 joints
Links:
- removed link grasp_box_base_link
- added link grasp_box2_base_link, mass 0.5; collision box size=0.1 0.1 0.1; visual box size=0.1 0.1 0.1
